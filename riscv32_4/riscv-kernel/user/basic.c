asm("j main");
#include "../lib/nwlib.h"


char instructions_msg[]= " \
\n\
                SIFIVE, INC.\n\
\n\
         5555555555555555555555555\n\
        5555                   5555\n\
       5555                     5555\n\
      5555                       5555\n\
     5555       5555555555555555555555\n\
    5555       555555555555555555555555\n\
   5555                             5555\n\
  5555                               5555\n\
 5555                                 5555\n\
5555555555555555555555555555          55555\n\
 55555           555555555           55555\n\
   55555           55555           55555\n\
     55555           5           55555\n\
       55555                   55555\n\
         55555               55555\n\
           55555           55555\n\
             55555       55555\n\
               55555   55555\n\
                 555555555\n\
                   55555\n\
                     5\n\
\n\
\n\
 ";
unsigned char rawData[246] = {
    0x6F, 0x00, 0xC0, 0x08, 0x13, 0x01, 0x01, 0xFE, 0x23, 0x2E, 0x81, 0x00,
    0x13, 0x04, 0x01, 0x02, 0x93, 0x07, 0x05, 0x00, 0xA3, 0x07, 0xF4, 0xFE,
    0xB7, 0xA7, 0x0F, 0x00, 0x93, 0x87, 0x27, 0x00, 0x03, 0x47, 0xF4, 0xFE,
    0x23, 0x80, 0xE7, 0x00, 0x13, 0x00, 0x00, 0x00, 0x03, 0x24, 0xC1, 0x01,
    0x13, 0x01, 0x01, 0x02, 0x67, 0x80, 0x00, 0x00, 0x13, 0x01, 0x01, 0xFE,
    0x23, 0x2E, 0x11, 0x00, 0x23, 0x2C, 0x81, 0x00, 0x13, 0x04, 0x01, 0x02,
    0x23, 0x26, 0xA4, 0xFE, 0x6F, 0x00, 0x00, 0x02, 0x83, 0x27, 0xC4, 0xFE,
    0x13, 0x87, 0x17, 0x00, 0x23, 0x26, 0xE4, 0xFE, 0x83, 0xC7, 0x07, 0x00,
    0x13, 0x85, 0x07, 0x00, 0x97, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xFA,
    0x83, 0x27, 0xC4, 0xFE, 0x83, 0xC7, 0x07, 0x00, 0xE3, 0x9E, 0x07, 0xFC,
    0x13, 0x00, 0x00, 0x00, 0x83, 0x20, 0xC1, 0x01, 0x03, 0x24, 0x81, 0x01,
    0x13, 0x01, 0x01, 0x02, 0x67, 0x80, 0x00, 0x00, 0x13, 0x01, 0x01, 0xFE,
    0x23, 0x2E, 0x11, 0x00, 0x23, 0x2C, 0x81, 0x00, 0x13, 0x04, 0x01, 0x02,
    0x97, 0x07, 0x00, 0x00, 0x93, 0x87, 0x07, 0x05, 0x23, 0x24, 0xF4, 0xFE,
    0x23, 0x26, 0x04, 0xFE, 0x6F, 0x00, 0xC0, 0x01, 0x03, 0x25, 0x84, 0xFE,
    0x97, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x40, 0xF8, 0x83, 0x27, 0xC4, 0xFE,
    0x93, 0x87, 0x17, 0x00, 0x23, 0x26, 0xF4, 0xFE, 0x03, 0x27, 0xC4, 0xFE,
    0x93, 0x07, 0x90, 0x00, 0xE3, 0xD0, 0xE7, 0xFE, 0x13, 0x00, 0x00, 0x00,
    0x83, 0x20, 0xC1, 0x01, 0x03, 0x24, 0x81, 0x01, 0x13, 0x01, 0x01, 0x02,
    0x67, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x70, 0x75, 0x20,
    0x74, 0x65, 0x73, 0x74, 0x0A, 0x00
};

char str[]={"daniel quintero\n"};
char *ptr;

int d=899;
long d2=1002255;
float f=99.8;


float CalculoPi()
{
int i, j = 1;
      float pi = 0, rtdo;
 
      for (i = 0; i < 1000; i++){
          rtdo = 4 / (float)j;
 
               if (i % 2 == 1)
                  pi -= rtdo;
               else
                   pi += rtdo;
          j += 2;
      }
      return pi;
}


char cadena[]={"riscv application\n"};

void main(int pid,uint32_t funcpointer){
long t=0;
uint8_t o=0;

fprint(4499.88);


kill_task(pid);
 
while(1){
   if(get_time()-t>100){
      t=get_time();
      myprintf("%s",cadena);
      o++;
   }
   if(o==10)break;
}
ptr=str;

myprintf(ptr);
myprintf("%s\n",instructions_msg);
myprintf("%l , %l\n",d,d2);
fprint(f);
myprintf("\n");
strcpy(buff,"riscv32\n");
myprintf("%s\n",buff);


long t1=get_time();

for (uint32_t i = 0; i < 1000; ++i)
{
  myprintf("%l",i);
  if(!(i % 4))myprintf("\n");
}
long t2=get_time();
myprintf("tiempo transcurrido: %l\n",t2-t1);

 t1=get_time();
 void (*p)(void);
 p=(void*)rawData;
 (*p)();
 t2=get_time();
myprintf("tiempo transcurrido: %l\n",t2-t1);
 t1=get_time();
myprintf("calculo de pi:\n");
fprint(CalculoPi());
myprintf("\n");
t2=get_time();
myprintf("tiempo transcurrido: %l\n",t2-t1);



uint32_t sum=0;
for (int i = 0; i < sizeof(rawData); ++i)
{
     sum+=rawData[i];
}
myprintf("%l\n",sum);

kill_task(pid);
}
